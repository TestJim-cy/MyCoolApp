# IAR project MyCoolApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CY8C6247BZI-D54M4 Cypress CY8C6247BZI-D54M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CY_USING_HAL; CYHAL_UDB_SDIO; CY_APPNAME_mtb_example_psoc6_empty_app; CY8C6247BZI_D54; CY_TARGET_DEVICE=CY8C6247BZI_D54; TARGET_CY8CKIT_062_WIFI_BT; CY_TARGET_BOARD=CY8CKIT_062_WIFI_BT; COMPONENT_BSP_DESIGN_MODUS; COMPONENT_CM0P_SLEEP; COMPONENT_CM4; COMPONENT_PSOC6HAL; COMPONENT_SOFTFP; COMPONENT_UDB_SDIO_P2; DEBUG
  ICCARM.CCIncludePath2: .; libs; libs\TARGET_CY8CKIT-062-WIFI-BT; libs\TARGET_CY8CKIT-062-WIFI-BT\COMPONENT_BSP_DESIGN_MODUS; libs\TARGET_CY8CKIT-062-WIFI-BT\COMPONENT_BSP_DESIGN_MODUS\GeneratedSource; libs\capsense; libs\core-lib; libs\core-lib\include; libs\psoc6hal; libs\psoc6hal\COMPONENT_PSOC6HAL; libs\psoc6hal\COMPONENT_PSOC6HAL\include; libs\psoc6hal\COMPONENT_PSOC6HAL\include\pin_packages; libs\psoc6hal\COMPONENT_PSOC6HAL\include\triggers; libs\psoc6hal\include; libs\psoc6pdl; libs\psoc6pdl\cmsis; libs\psoc6pdl\cmsis\include; libs\psoc6pdl\devices; libs\psoc6pdl\devices\include; libs\psoc6pdl\devices\include\ip; libs\psoc6pdl\drivers; libs\psoc6pdl\drivers\include; libs\udb-sdio-whd; libs\udb-sdio-whd\COMPONENT_UDB_SDIO_P2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: MyCoolApp.out
  ILINK.IlinkExtraOptions: libs\capsense\COMPONENT_SOFTFP\TOOLCHAIN_IAR\libcy_capsense.a
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CY_USING_HAL; CYHAL_UDB_SDIO; CY_APPNAME_mtb_example_psoc6_empty_app; CY8C6247BZI_D54; CY_TARGET_DEVICE=CY8C6247BZI_D54; TARGET_CY8CKIT_062_WIFI_BT; CY_TARGET_BOARD=CY8CKIT_062_WIFI_BT; COMPONENT_BSP_DESIGN_MODUS; COMPONENT_CM0P_SLEEP; COMPONENT_CM4; COMPONENT_PSOC6HAL; COMPONENT_SOFTFP; COMPONENT_UDB_SDIO_P2; DEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: mtb-example-psoc6-empty-app.ipcf
  group mtb-example-psoc6-empty-app
    ./: main.c
  group mtb-example-psoc6-empty-app/capsense/Header
    libs/capsense/: cy_capsense.h cy_capsense_centroid.h cy_capsense_common.h cy_capsense_control.h cy_capsense_csd.h cy_capsense_csx.h cy_capsense_filter.h cy_capsense_gesture_lib.h cy_capsense_lib.h cy_capsense_processing.h cy_capsense_sensing.h cy_capsense_structure.h cy_capsense_tuner.h
  group mtb-example-psoc6-empty-app/capsense/Source
    libs/capsense/: cy_capsense_centroid.c cy_capsense_control.c cy_capsense_csd.c cy_capsense_csx.c cy_capsense_filter.c cy_capsense_processing.c cy_capsense_sensing.c cy_capsense_structure.c cy_capsense_tuner.c
  group mtb-example-psoc6-empty-app/core-lib/Header
    libs/core-lib/include/: cy_result.h cy_utils.h
  group mtb-example-psoc6-empty-app/psoc6cm0p/Source
    libs/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_01_cm0p_sleep.c psoc6_02_cm0p_sleep.c psoc6_03_cm0p_sleep.c
  group mtb-example-psoc6-empty-app/psoc6hal/Header
    libs/psoc6hal/include/: cyhal.h cyhal_adc.h cyhal_clock.h cyhal_crc.h cyhal_dac.h cyhal_dma.h cyhal_ezi2c.h cyhal_flash.h cyhal_general_types.h cyhal_gpio.h cyhal_hwmgr.h cyhal_i2c.h cyhal_i2s.h cyhal_interconnect.h cyhal_lptimer.h cyhal_pdmpcm.h cyhal_pwm.h cyhal_qspi.h cyhal_rtc.h cyhal_sdhc.h cyhal_sdio.h cyhal_spi.h cyhal_syspm.h cyhal_system.h cyhal_timer.h cyhal_trng.h cyhal_uart.h cyhal_usb_dev.h cyhal_wdt.h
    libs/psoc6hal/COMPONENT_PSOC6HAL/include/: cyhal_analog_common.h cyhal_clock_impl.h cyhal_crc_impl.h cyhal_crypto_common.h cyhal_deprecated.h cyhal_dma_dmac.h cyhal_dma_dw.h cyhal_dma_impl.h cyhal_gpio_impl.h cyhal_hw_resources.h cyhal_hw_types.h cyhal_pin_package.h cyhal_pwm_impl.h cyhal_scb_common.h cyhal_syspm_impl.h cyhal_system_impl.h cyhal_tcpwm_common.h cyhal_timer_impl.h cyhal_triggers.h cyhal_trng_impl.h cyhal_utils.h
    libs/psoc6hal/COMPONENT_PSOC6HAL/include/pin_packages/: cyhal_psoc6_01_104_m_csp_ble.h cyhal_psoc6_01_104_m_csp_ble_usb.h cyhal_psoc6_01_116_bga_ble.h cyhal_psoc6_01_116_bga_usb.h cyhal_psoc6_01_124_bga.h cyhal_psoc6_01_124_bga_sip.h cyhal_psoc6_01_43_smt.h cyhal_psoc6_01_68_qfn_ble.h cyhal_psoc6_01_80_wlcsp.h cyhal_psoc6_02_100_wlcsp.h cyhal_psoc6_02_124_bga.h cyhal_psoc6_02_128_tqfp.h cyhal_psoc6_02_68_qfn.h cyhal_psoc6_03_100_tqfp.h cyhal_psoc6_03_49_wlcsp.h cyhal_psoc6_03_68_qfn.h
    libs/psoc6hal/COMPONENT_PSOC6HAL/include/triggers/: cyhal_triggers_psoc6_01.h cyhal_triggers_psoc6_02.h cyhal_triggers_psoc6_03.h
  group mtb-example-psoc6-empty-app/psoc6hal/Source
    libs/psoc6hal/COMPONENT_PSOC6HAL/source/: cyhal_adc.c cyhal_analog_common.c cyhal_clock.c cyhal_crc.c cyhal_crypto_common.c cyhal_dac.c cyhal_deprecated.c cyhal_dma.c cyhal_dma_dmac.c cyhal_dma_dw.c cyhal_ezi2c.c cyhal_flash.c cyhal_gpio.c cyhal_hwmgr.c cyhal_i2c.c cyhal_i2s.c cyhal_interconnect.c cyhal_lptimer.c cyhal_not_implemented.c cyhal_pdmpcm.c cyhal_pwm.c cyhal_qspi.c cyhal_rtc.c cyhal_scb_common.c cyhal_sdhc.c cyhal_spi.c cyhal_syspm.c cyhal_system.c cyhal_tcpwm_common.c cyhal_timer.c cyhal_trng.c cyhal_uart.c cyhal_udb_sdio.c cyhal_usb_dev.c cyhal_utils.c cyhal_wdt.c
    libs/psoc6hal/COMPONENT_PSOC6HAL/source/pin_packages/: cyhal_psoc6_01_104_m_csp_ble.c cyhal_psoc6_01_104_m_csp_ble_usb.c cyhal_psoc6_01_116_bga_ble.c cyhal_psoc6_01_116_bga_usb.c cyhal_psoc6_01_124_bga.c cyhal_psoc6_01_124_bga_sip.c cyhal_psoc6_01_43_smt.c cyhal_psoc6_01_68_qfn_ble.c cyhal_psoc6_01_80_wlcsp.c cyhal_psoc6_02_100_wlcsp.c cyhal_psoc6_02_124_bga.c cyhal_psoc6_02_128_tqfp.c cyhal_psoc6_02_68_qfn.c cyhal_psoc6_03_100_tqfp.c cyhal_psoc6_03_49_wlcsp.c cyhal_psoc6_03_68_qfn.c
    libs/psoc6hal/COMPONENT_PSOC6HAL/source/triggers/: cyhal_triggers_psoc6_01.c cyhal_triggers_psoc6_02.c cyhal_triggers_psoc6_03.c
  group mtb-example-psoc6-empty-app/psoc6pdl/Header
    libs/psoc6pdl/cmsis/include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h mpu_armv7.h mpu_armv8.h
    libs/psoc6pdl/devices/include/: cy8c6016bzi_f04.h cy8c6036bzi_f04.h cy8c6116bzi_f54.h cy8c6117bzi_f34.h cy8c6117fdi_f02.h cy8c6117wi_f34.h cy8c6136bzi_f14.h cy8c6136bzi_f34.h cy8c6136fdi_f42.h cy8c6136fti_f42.h cy8c6137bzi_f14.h cy8c6137bzi_f34.h cy8c6137bzi_f54.h cy8c6137fdi_f02.h cy8c6137wi_f54.h cy8c6244azi_s4d12.h cy8c6244azi_s4d62.h cy8c6244azi_s4d82.h cy8c6244azi_s4d83.h cy8c6244azi_s4d92.h cy8c6244azi_s4d93.h cy8c6244lqi_s4d12.h cy8c6244lqi_s4d62.h cy8c6244lqi_s4d82.h cy8c6244lqi_s4d92.h cy8c6245azi_s3d02.h cy8c6245azi_s3d12.h cy8c6245azi_s3d42.h cy8c6245azi_s3d62.h cy8c6245azi_s3d72.h cy8c6245fni_s3d11.h cy8c6245fni_s3d41.h cy8c6245fni_s3d71.h cy8c6245lqi_s3d02.h cy8c6245lqi_s3d12.h cy8c6245lqi_s3d42.h cy8c6245lqi_s3d62.h cy8c6245lqi_s3d72.h cy8c6245w_s3d72.h cy8c6246bzi_d04.h cy8c6247bfi_d54.h cy8c6247bzi_aud54.h cy8c6247bzi_d34.h cy8c6247bzi_d44.h cy8c6247bzi_d54.h cy8c6247fdi_d02.h cy8c6247fdi_d32.h cy8c6247fdi_d52.h cy8c6247fti_d52.h cy8c6247wi_d54.h cy8c6248azi_d14.h cy8c6248azi_d44.h cy8c6248azi_s2d14.h cy8c6248azi_s2d44.h cy8c6248bzi_d44.h cy8c6248bzi_s2d44.h cy8c6248fni_d43.h cy8c6248fni_s2d43.h cy8c624aazi_d14.h cy8c624aazi_d44.h cy8c624aazi_s2d14.h cy8c624aazi_s2d44.h cy8c624abzi_d04.h cy8c624abzi_d14.h cy8c624abzi_d44.h cy8c624abzi_s2d04.h cy8c624abzi_s2d14.h cy8c624abzi_s2d44.h cy8c624abzi_s2d44a0.h cy8c624afni_d43.h cy8c624afni_s2d43.h cy8c624alqi_d42.h cy8c6316bzi_blf03.h cy8c6316bzi_blf04.h cy8c6316bzi_blf53.h cy8c6316bzi_blf54.h cy8c6336bzi_bld13.h cy8c6336bzi_bld14.h cy8c6336bzi_blf03.h cy8c6336bzi_blf04.h cy8c6336bzi_bud13.h cy8c6336lqi_blf02.h cy8c6336lqi_blf42.h cy8c6337bzi_blf13.h cy8c6347bzi_bld33.h cy8c6347bzi_bld34.h cy8c6347bzi_bld43.h cy8c6347bzi_bld44.h cy8c6347bzi_bld53.h cy8c6347bzi_bld54.h cy8c6347bzi_bud33.h cy8c6347bzi_bud43.h cy8c6347bzi_bud53.h cy8c6347fmi_bld13.h cy8c6347fmi_bld33.h cy8c6347fmi_bld43.h cy8c6347fmi_bld53.h cy8c6347fmi_bud13.h cy8c6347fmi_bud33.h cy8c6347fmi_bud43.h cy8c6347fmi_bud53.h cy8c6347lqi_bld52.h cy8c637bzi_bld74.h cy8c637bzi_md76.h cy8c637fmi_bld73.h cy8c68237bz_ble.h cy8c68237fm_ble.h cy_device_common.h cy_device_headers.h cyb06445lqi_s3d42.h cyb06447bzi_bld53.h cyb06447bzi_bld54.h cyb06447bzi_d54.h cyb0644abzi_s2d44.h cyble_416045_02.h cys0644abzi_s2d44.h gpio_psoc6_01_104_m_csp_ble.h gpio_psoc6_01_104_m_csp_ble_usb.h gpio_psoc6_01_116_bga_ble.h gpio_psoc6_01_116_bga_usb.h gpio_psoc6_01_124_bga.h gpio_psoc6_01_124_bga_sip.h gpio_psoc6_01_43_smt.h gpio_psoc6_01_68_qfn_ble.h gpio_psoc6_01_80_wlcsp.h gpio_psoc6_02_100_wlcsp.h gpio_psoc6_02_124_bga.h gpio_psoc6_02_128_tqfp.h gpio_psoc6_02_68_qfn.h gpio_psoc6_03_100_tqfp.h gpio_psoc6_03_49_wlcsp.h gpio_psoc6_03_68_qfn.h gpio_psoc6_04_64_tqfp.h gpio_psoc6_04_68_qfn.h gpio_psoc6_04_80_tqfp.h psoc6_01_config.h psoc6_02_config.h psoc6_03_config.h psoc6_04_config.h
    libs/psoc6pdl/drivers/include/: cy_ble_clk.h cy_canfd.h cy_crypto.h cy_crypto_common.h cy_crypto_core.h cy_crypto_core_aes.h cy_crypto_core_aes_v1.h cy_crypto_core_aes_v2.h cy_crypto_core_cmac.h cy_crypto_core_cmac_v1.h cy_crypto_core_cmac_v2.h cy_crypto_core_crc.h cy_crypto_core_crc_v1.h cy_crypto_core_crc_v2.h cy_crypto_core_des.h cy_crypto_core_des_v1.h cy_crypto_core_des_v2.h cy_crypto_core_ecc.h cy_crypto_core_ecc_nist_p.h cy_crypto_core_hmac.h cy_crypto_core_hmac_v1.h cy_crypto_core_hmac_v2.h cy_crypto_core_hw.h cy_crypto_core_hw_v1.h cy_crypto_core_hw_v2.h cy_crypto_core_hw_vu.h cy_crypto_core_mem.h cy_crypto_core_mem_v1.h cy_crypto_core_mem_v2.h cy_crypto_core_prng.h cy_crypto_core_prng_v1.h cy_crypto_core_prng_v2.h cy_crypto_core_rsa.h cy_crypto_core_sha.h cy_crypto_core_sha_v1.h cy_crypto_core_sha_v2.h cy_crypto_core_trng.h cy_crypto_core_trng_config_v1.h cy_crypto_core_trng_config_v2.h cy_crypto_core_trng_v1.h cy_crypto_core_trng_v2.h cy_crypto_core_vu.h cy_crypto_server.h cy_csd.h cy_ctb.h cy_ctdac.h cy_device.h cy_dma.h cy_dmac.h cy_efuse.h cy_flash.h cy_gpio.h cy_i2s.h cy_ipc_drv.h cy_ipc_pipe.h cy_ipc_sema.h cy_lpcomp.h cy_lvd.h cy_mcwdt.h cy_pdl.h cy_pdm_pcm.h cy_profile.h cy_prot.h cy_rtc.h cy_sar.h cy_scb_common.h cy_scb_ezi2c.h cy_scb_i2c.h cy_scb_spi.h cy_scb_uart.h cy_sd_host.h cy_seglcd.h cy_smartio.h cy_smif.h cy_smif_memslot.h cy_sysanalog.h cy_sysclk.h cy_sysint.h cy_syslib.h cy_syspm.h cy_systick.h cy_tcpwm.h cy_tcpwm_counter.h cy_tcpwm_pwm.h cy_tcpwm_quaddec.h cy_trigmux.h cy_usbfs_dev_drv.h cy_usbfs_dev_drv_pvt.h cy_usbfs_dev_drv_reg.h cy_wdt.h
    libs/psoc6pdl/devices/include/ip/: cyip_backup.h cyip_ble.h cyip_canfd.h cyip_cpuss.h cyip_cpuss_v2.h cyip_crypto.h cyip_crypto_v2.h cyip_csd.h cyip_ctbm.h cyip_ctbm_v2.h cyip_ctdac.h cyip_ctdac_v2.h cyip_dmac_v2.h cyip_dw.h cyip_dw_v2.h cyip_efuse.h cyip_efuse_data_psoc6_01.h cyip_efuse_data_psoc6_02.h cyip_efuse_data_psoc6_03.h cyip_efuse_data_psoc6_04.h cyip_fault.h cyip_fault_v2.h cyip_flashc.h cyip_flashc_v2.h cyip_gpio.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom.h cyip_hsiom_v2.h cyip_i2s.h cyip_ipc.h cyip_ipc_v2.h cyip_lcd.h cyip_lcd_v2.h cyip_lpcomp.h cyip_pass.h cyip_pass_v2.h cyip_pdm.h cyip_peri.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_profile.h cyip_prot.h cyip_prot_v2.h cyip_sar.h cyip_sar_v2.h cyip_scb.h cyip_sdhc.h cyip_sflash.h cyip_smartio.h cyip_smartio_v2.h cyip_smif.h cyip_srss.h cyip_tcpwm.h cyip_tcpwm_v2.h cyip_udb.h cyip_usbfs.h
  group mtb-example-psoc6-empty-app/psoc6pdl/Source
    libs/psoc6pdl/drivers/source/: cy_ble_clk.c cy_canfd.c cy_crypto.c cy_crypto_core_aes_v1.c cy_crypto_core_aes_v2.c cy_crypto_core_cmac_v1.c cy_crypto_core_cmac_v2.c cy_crypto_core_crc_v1.c cy_crypto_core_crc_v2.c cy_crypto_core_des_v1.c cy_crypto_core_des_v2.c cy_crypto_core_ecc_domain_params.c cy_crypto_core_ecc_ecdsa.c cy_crypto_core_ecc_key_gen.c cy_crypto_core_ecc_nist_p.c cy_crypto_core_hmac_v1.c cy_crypto_core_hmac_v2.c cy_crypto_core_hw.c cy_crypto_core_hw_v1.c cy_crypto_core_mem_v1.c cy_crypto_core_mem_v2.c cy_crypto_core_prng_v1.c cy_crypto_core_prng_v2.c cy_crypto_core_rsa.c cy_crypto_core_sha_v1.c cy_crypto_core_sha_v2.c cy_crypto_core_trng_v1.c cy_crypto_core_trng_v2.c cy_crypto_core_vu.c cy_crypto_server.c cy_csd.c cy_ctb.c cy_ctdac.c cy_device.c cy_dma.c cy_dmac.c cy_efuse.c cy_flash.c cy_gpio.c cy_i2s.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c cy_lpcomp.c cy_lvd.c cy_mcwdt.c cy_pdm_pcm.c cy_profile.c cy_prot.c cy_rtc.c cy_sar.c cy_scb_common.c cy_scb_ezi2c.c cy_scb_i2c.c cy_scb_spi.c cy_scb_uart.c cy_sd_host.c cy_seglcd.c cy_smartio.c cy_smif.c cy_smif_memslot.c cy_sysanalog.c cy_sysclk.c cy_sysint.c cy_syslib.c cy_syspm.c cy_systick.c cy_tcpwm_counter.c cy_tcpwm_pwm.c cy_tcpwm_quaddec.c cy_trigmux.c cy_usbfs_dev_drv.c cy_usbfs_dev_drv_io.c cy_usbfs_dev_drv_io_dma.c cy_wdt.c
    libs/psoc6pdl/drivers/source/TOOLCHAIN_IAR/: cy_syslib_iar.s
  group mtb-example-psoc6-empty-app/TARGET_CY8CKIT-062-WIFI-BT/Header
    libs/TARGET_CY8CKIT-062-WIFI-BT/: cybsp.h cybsp_types.h system_psoc6.h
    libs/TARGET_CY8CKIT-062-WIFI-BT/COMPONENT_BSP_DESIGN_MODUS/GeneratedSource/: cycfg.h cycfg_capsense.h cycfg_clocks.h cycfg_notices.h cycfg_peripherals.h cycfg_pins.h cycfg_qspi_memslot.h cycfg_routing.h cycfg_system.h
  group mtb-example-psoc6-empty-app/TARGET_CY8CKIT-062-WIFI-BT/Source
    libs/TARGET_CY8CKIT-062-WIFI-BT/: cybsp.c
    libs/TARGET_CY8CKIT-062-WIFI-BT/COMPONENT_BSP_DESIGN_MODUS/GeneratedSource/: cycfg.c cycfg_capsense.c cycfg_clocks.c cycfg_peripherals.c cycfg_pins.c cycfg_qspi_memslot.c cycfg_routing.c cycfg_system.c
    libs/TARGET_CY8CKIT-062-WIFI-BT/COMPONENT_CM4/TOOLCHAIN_IAR/: startup_psoc6_01_cm4.s
    libs/TARGET_CY8CKIT-062-WIFI-BT/COMPONENT_CM4/: system_psoc6_cm4.c
  group mtb-example-psoc6-empty-app/udb-sdio-whd/Header
    libs/udb-sdio-whd/: SDIO_HOST.h
    libs/udb-sdio-whd/COMPONENT_UDB_SDIO_P2/: SDIO_HOST_cfg.h
  group mtb-example-psoc6-empty-app/udb-sdio-whd/Source
    libs/udb-sdio-whd/: SDIO_HOST.c
    libs/udb-sdio-whd/COMPONENT_UDB_SDIO_P2/: SDIO_HOST_cfg.c
